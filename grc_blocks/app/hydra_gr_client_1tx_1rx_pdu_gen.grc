<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>hydra_gr_client_1tx_1rx_pdu_gen</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>mul1</value></param>
<param><key>value</key><value>0.06</value></param>
<param><key>label</key><value>mul1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>occupied_carriers</value></param>
<param><key>value</key><value>(range(-26, -21) + range(-20, -7) + range(-6, 0) + range(1, 7) + range(8, 21) + range(22, 27),)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_carriers</value></param>
<param><key>value</key><value>((-21, -7, 7, 21,),)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_symbols</value></param>
<param><key>value</key><value>((1, 1, 1, -1,),)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_word1</value></param>
<param><key>value</key><value>[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_word2</value></param>
<param><key>value</key><value>[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0] </value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>100</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>mul1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>"len"</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>2</value></param>
<param><key>maxsize</key><value>100</value></param>
<param><key>minsize</key><value>50</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>name</key><value>VR1 RX</value></param>
</block>
<block>
<key>digital_ofdm_rx</key>
<param><key>id</key><value>digital_ofdm_rx_0</value></param>
<param><key>cp_len</key><value>16</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_len</key><value>64</value></param>
<param><key>header_mod</key><value>"BPSK"</value></param>
<param><key>packet_len_key</key><value>"len"</value></param>
<param><key>payload_mod</key><value>"BPSK"</value></param>
</block>
<block>
<key>digital_ofdm_tx</key>
<param><key>id</key><value>digital_ofdm_tx_0</value></param>
<param><key>cp_len</key><value>16</value></param>
<param><key>fft_len</key><value>64</value></param>
<param><key>header_mod</key><value>"BPSK"</value></param>
<param><key>packet_len_key</key><value>"len" </value></param>
<param><key>payload_mod</key><value>"BPSK"</value></param>
<param><key>rolloff</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freqrx</value></param>
<param><key>value</key><value>1.1e9</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freqtx</value></param>
<param><key>value</key><value>1.1e9</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>hydraClient</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>192.168.5.77</value></param>
</block>
<block>
<key>hydra_gr__source</key>
<param><key>id</key><value>hydra_gr__source_0_0</value></param>
<param><key>center_frequency</key><value>freqtx + vr1offset</value></param>
<param><key>c_host</key><value>hydraClient</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>payload</key><value>5000</value></param>
<param><key>port</key><value>5000</value></param>
<param><key>samp_rate</key><value>samp_rate * 2</value></param>
<param><key>u_id</key><value>1</value></param>
</block>
<block>
<key>hydra_gr_sink</key>
<param><key>id</key><value>hydra_gr_sink_0</value></param>
<param><key>center_frequency</key><value>freqtx + vr1offset</value></param>
<param><key>host</key><value>hydraClient</value></param>
<param><key>payload</key><value>1000</value></param>
<param><key>port</key><value>5000</value></param>
<param><key>samp_rate</key><value>samp_rate * 2</value></param>
<param><key>u_id</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>200e3</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>freqtx + vr1offset</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>0.7</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate * 2</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>vr1offset</value></param>
<param><key>value</key><value>-300e3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>vr2offset</value></param>
<param><key>value</key><value>700e3</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>hydra_gr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>digital_ofdm_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>digital_ofdm_rx_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_tx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hydra_gr__source_0_0</source_block_id><sink_block_id>digital_ofdm_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
