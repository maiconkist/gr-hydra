<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ansible_hydra_gr_client_2tx_2rx</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>0.06</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>0.06</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>"len"</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>"len"</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>2</value></param>
<param><key>maxsize</key><value>60</value></param>
<param><key>minsize</key><value>50</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>name</key><value>VR1 RX</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>name</key><value>VR2 RX</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>"len"</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>"len"</value></param>
</block>
<block>
<key>blocks_tuntap_pdu</key>
<param><key>id</key><value>blocks_tuntap_pdu_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>istunflag</key><value>False</value></param>
<param><key>ifn</key><value>tap0</value></param>
<param><key>mtu</key><value>10000</value></param>
</block>
<block>
<key>blocks_tuntap_pdu</key>
<param><key>id</key><value>blocks_tuntap_pdu_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>istunflag</key><value>False</value></param>
<param><key>ifn</key><value>tap1</value></param>
<param><key>mtu</key><value>10000</value></param>
</block>
<block>
<key>digital_ofdm_rx</key>
<param><key>id</key><value>digital_ofdm_rx_0</value></param>
<param><key>cp_len</key><value>16</value></param>
<param><key>fft_len</key><value>64</value></param>
<param><key>header_mod</key><value>"BPSK"</value></param>
<param><key>packet_len_key</key><value>"len"</value></param>
<param><key>payload_mod</key><value>"BPSK"</value></param>
</block>
<block>
<key>digital_ofdm_rx</key>
<param><key>id</key><value>digital_ofdm_rx_0_0</value></param>
<param><key>cp_len</key><value>16</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_len</key><value>64</value></param>
<param><key>header_mod</key><value>"BPSK"</value></param>
<param><key>packet_len_key</key><value>"len"</value></param>
<param><key>payload_mod</key><value>"BPSK"</value></param>
</block>
<block>
<key>digital_ofdm_tx</key>
<param><key>id</key><value>digital_ofdm_tx_0</value></param>
<param><key>cp_len</key><value>16</value></param>
<param><key>fft_len</key><value>64</value></param>
<param><key>header_mod</key><value>"BPSK"</value></param>
<param><key>packet_len_key</key><value>"len"</value></param>
<param><key>payload_mod</key><value>"BPSK"</value></param>
<param><key>rolloff</key><value>0</value></param>
</block>
<block>
<key>digital_ofdm_tx</key>
<param><key>id</key><value>digital_ofdm_tx_0_0</value></param>
<param><key>cp_len</key><value>16</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_len</key><value>64</value></param>
<param><key>header_mod</key><value>"BPSK"</value></param>
<param><key>packet_len_key</key><value>"len"</value></param>
<param><key>payload_mod</key><value>"BPSK"</value></param>
<param><key>rolloff</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freqrx</value></param>
<param><key>value</key><value>1.2e9</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freqtx</value></param>
<param><key>value</key><value>1.1e9</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>hydraClient</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>192.168.5.77</value></param>
</block>
<block>
<key>hydra_gr__source</key>
<param><key>id</key><value>hydra_gr__source_0_0</value></param>
<param><key>center_frequency</key><value>freqrx + vr1offset</value></param>
<param><key>c_host</key><value>hydraClient</value></param>
<param><key>payload</key><value>10000</value></param>
<param><key>port</key><value>5000</value></param>
<param><key>samp_rate</key><value>samp_rate * 2</value></param>
<param><key>u_id</key><value>1</value></param>
</block>
<block>
<key>hydra_gr__source</key>
<param><key>id</key><value>hydra_gr__source_0_0_0</value></param>
<param><key>center_frequency</key><value>freqrx + vr2offset</value></param>
<param><key>c_host</key><value>hydraClient</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>payload</key><value>10000</value></param>
<param><key>port</key><value>5000</value></param>
<param><key>samp_rate</key><value>samp_rate * 2</value></param>
<param><key>u_id</key><value>1</value></param>
</block>
<block>
<key>hydra_gr_sink</key>
<param><key>id</key><value>hydra_gr_sink_0</value></param>
<param><key>center_frequency</key><value>freqtx + vr1offset</value></param>
<param><key>host</key><value>hydraClient</value></param>
<param><key>payload</key><value>1024</value></param>
<param><key>port</key><value>5000</value></param>
<param><key>samp_rate</key><value>samp_rate * 2</value></param>
<param><key>u_id</key><value>1</value></param>
</block>
<block>
<key>hydra_gr_sink</key>
<param><key>id</key><value>hydra_gr_sink_0_0</value></param>
<param><key>center_frequency</key><value>freqtx + vr2offset</value></param>
<param><key>host</key><value>hydraClient</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>payload</key><value>1024</value></param>
<param><key>port</key><value>5000</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>u_id</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>200e3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>vr1offset</value></param>
<param><key>value</key><value>-300e3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>vr2offset</value></param>
<param><key>value</key><value>700e3</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>hydra_gr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>hydra_gr_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>digital_ofdm_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_0</source_block_id><sink_block_id>digital_ofdm_tx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>blocks_tuntap_pdu_1</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0_0</source_block_id><sink_block_id>blocks_tuntap_pdu_1_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_tuntap_pdu_1</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_tuntap_pdu_1_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>digital_ofdm_rx_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_rx_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_rx_0_0</source_block_id><sink_block_id>blocks_tag_debug_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_rx_0_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_tx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_tx_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hydra_gr__source_0_0</source_block_id><sink_block_id>digital_ofdm_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hydra_gr__source_0_0_0</source_block_id><sink_block_id>digital_ofdm_rx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
