options:
  parameters:
    generate_options: qt_gui
    id: ansible_hydra_gr_client_1tx_1rx
    output_language: python
    run_options: run
  states: {}

blocks:
- name: mul
  id: variable_qtgui_range
  parameters:
    label: mul
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.04'
  states: {}
- name: ansibleIP
  id: parameter
  parameters:
    type: str
    value: 192.168.5.251
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: mul
    type: complex
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: '"len"'
    type: byte
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    name: VR1 RX
    type: byte
  states: {}
- name: blocks_tag_debug_1
  id: blocks_tag_debug
  parameters:
    name: VR1 TX
    type: complex
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: '"len"'
    type: byte
  states: {}
- name: blocks_tuntap_pdu_1
  id: network_tuntap_pdu
  parameters:
    ifn: tap0
    istunflag: 'False'
    maxoutbuf: '100000'
    mtu: '1000'
  states: {}
- name: digital_ofdm_rx_0
  id: digital_ofdm_rx
  parameters:
    cp_len: '16'
    fft_len: '64'
    header_mod: '"BPSK"'
    occupied_carriers: ''
    packet_len_key: '"len"'
    payload_mod: '"BPSK"'
    pilot_carriers: ''
    pilot_symbols: ''
    sync_word1: ''
    sync_word2: ''
  states: {}
- name: digital_ofdm_tx_0
  id: digital_ofdm_tx
  parameters:
    cp_len: '16'
    fft_len: '64'
    header_mod: '"BPSK"'
    occupied_carriers: ''
    packet_len_key: '"len"'
    payload_mod: '"BPSK"'
    pilot_carriers: ''
    pilot_symbols: ''
    rolloff: '0'
    sync_word1: ''
    sync_word2: ''
  states: {}
- name: freqrx
  id: parameter
  parameters:
    value: 1.1e9 + 5e6
  states: {}
- name: freqtx
  id: parameter
  parameters:
    value: 1.1e9
  states: {}
- name: hydra_gr_sink_0
  id: hydra_gr_sink
  parameters:
    center_frequency: freqtx + vr1offset
    group: default
    host: ansibleIP
    payload: '1024'
    port: '5000'
    samp_rate: samp_rate * 2
    u_id: '1'
  states: {}
- name: hydra_gr_source_0
  id: hydra_gr_source
  parameters:
    center_frequency: freqrx + vr1offset
    group: default
    host: ansibleIP
    payload: '5000'
    port: '5000'
    samp_rate: samp_rate * 2
    u_id: '1'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    value: 200e3
  states: {}
- name: vr1offset
  id: parameter
  parameters:
    value: '-300e3'
  states: {}
- name: vr2offset
  id: parameter
  parameters:
    value: 700e3
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', hydra_gr_sink_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', digital_ofdm_tx_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, blocks_tuntap_pdu_1, pdus]
- [blocks_tuntap_pdu_1, pdus, blocks_pdu_to_tagged_stream_0, pdus]
- [digital_ofdm_rx_0, '0', blocks_tag_debug_0, '0']
- [digital_ofdm_rx_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [digital_ofdm_tx_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_ofdm_tx_0, '0', blocks_tag_debug_1, '0']
- [hydra_gr_source_0, '0', digital_ofdm_rx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
