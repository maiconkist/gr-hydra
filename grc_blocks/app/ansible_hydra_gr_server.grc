options:
  parameters:
    author: ''
    catch_exceptions: 'True'
    category: '[GRC Hier Blocks]'
    cmake_opt: ''
    comment: ''
    copyright: ''
    description: ''
    gen_cmake: 'On'
    gen_linking: dynamic
    generate_options: no_gui
    hier_block_src_path: '.:'
    id: ansible_hydra_gr_server
    max_nouts: '0'
    output_language: python
    placement: (0,0)
    qt_qss_theme: ''
    realtime_scheduling: ''
    run: 'True'
    run_command: '{python} -u {filename}'
    run_options: run
    sizing_mode: fixed
    thread_safe_setters: ''
    title: ''
    window_size: ''
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate: [8, 8]
    rotation: 0
    state: enabled

blocks:
- name: ahydra_gr_server_0
  id: hydra_gr_server
  parameters:
    alias: ''
    comment: ''
    group: default
    ip: ansibleIPPort
    mode: '"USRP"'
    rx_center_frequency: freqrx
    rx_fft_size: '2048'
    rx_norm_gain: '0.0'
    rx_samp_rate: 2e6
    tx_center_frequency: freqtx
    tx_fft_size: '2048'
    tx_norm_gain: '0.6'
    tx_samp_rate: 2e6
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate: [808, 124]
    rotation: 0
    state: enabled
- name: ansibleIPPort
  id: parameter
  parameters:
    alias: ''
    comment: ''
    hide: none
    label: ''
    short_id: ''
    type: str
    value: 192.168.5.251:5000
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate: [632, 24]
    rotation: 0
    state: enabled
- name: freqrx
  id: parameter
  parameters:
    alias: ''
    comment: ''
    hide: none
    label: ''
    short_id: ''
    type: eng_float
    value: 1.1e9+5e6
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate: [432, 40]
    rotation: 0
    state: enabled
- name: freqtx
  id: parameter
  parameters:
    alias: ''
    comment: ''
    hide: none
    label: ''
    short_id: ''
    type: eng_float
    value: 1.1e9
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate: [328, 40]
    rotation: 0
    state: enabled
connections: []

metadata:
  file_format: 1
  grc_version: 3.10.9.2
