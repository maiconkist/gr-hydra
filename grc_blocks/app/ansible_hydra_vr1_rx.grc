options:
  parameters:
    generate_options: no_gui
    id: ansible_hydra_vr1_rx
    output_language: python
    run_options: run
  states: {}

blocks:
- name: gain
  id: variable_qtgui_range
  parameters:
    label: gain
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.7'
  states: {state: disabled}
- name: mul
  id: variable_qtgui_range
  parameters:
    label: mul
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.04'
  states: {state: disabled}
- name: ansibleIP
  id: parameter
  parameters:
    type: str
    value: 192.168.5.78
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: mul
    type: complex
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: '"len"'
    type: byte
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    name: VR1 RX
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: '"len"'
    type: byte
  states: {}
- name: blocks_tuntap_pdu_1_0
  id: network_tuntap_pdu
  parameters:
    ifn: tap0
    istunflag: 'False'
    mtu: '200'
  states: {}
- name: digital_ofdm_rx_0_0
  id: digital_ofdm_rx
  parameters:
    cp_len: '16'
    fft_len: '64'
    header_mod: '"BPSK"'
    occupied_carriers: ''
    packet_len_key: '"len"'
    payload_mod: '"BPSK"'
    pilot_carriers: ''
    pilot_symbols: ''
    sync_word1: ''
    sync_word2: ''
  states: {}
- name: digital_ofdm_tx_0_0
  id: digital_ofdm_tx
  parameters:
    cp_len: '16'
    fft_len: '64'
    header_mod: '"BPSK"'
    occupied_carriers: ''
    packet_len_key: '"len"'
    payload_mod: '"BPSK"'
    pilot_carriers: ''
    pilot_symbols: ''
    rolloff: '0'
    sync_word1: ''
    sync_word2: ''
  states: {}
- name: freqrx
  id: parameter
  parameters:
    value: 1.1e9
  states: {}
- name: freqtx
  id: parameter
  parameters:
    value: 1.1e9+5e6
  states: {}
- name: gain
  id: parameter
  parameters:
    value: '0.85'
  states: {}
- name: mul
  id: parameter
  parameters:
    value: '0.04'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {state: disabled}
- name: samp_rate
  id: parameter
  parameters:
    value: 400e3
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: freqtx + vr1offset
    clock_rate: '0.0'
    dev_args: '""'
    gain0: gain
    gain_type0: normalized
    len_tag_name: ''
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freqrx + vr1offset
    clock_rate: '0.0'
    dev_args: '""'
    gain0: '0'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: vr1offset
  id: parameter
  parameters:
    value: '-300e3'
  states: {}
- name: vr2offset
  id: parameter
  parameters:
    value: 700e3
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: ansibleIP
    port: '8080'
  states: {}

connections:
- [blocks_multiply_const_vxx_0_0, '0', uhd_usrp_sink_0, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', digital_ofdm_tx_0_0, '0']
- [blocks_tagged_stream_to_pdu_0_0, pdus, blocks_tuntap_pdu_1_0, pdus]
- [blocks_tuntap_pdu_1_0, pdus, blocks_pdu_to_tagged_stream_0_0, pdus]
- [digital_ofdm_rx_0_0, '0', blocks_tag_debug_0, '0']
- [digital_ofdm_rx_0_0, '0', blocks_tagged_stream_to_pdu_0_0, '0']
- [digital_ofdm_tx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [uhd_usrp_source_0, '0', digital_ofdm_rx_0_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
